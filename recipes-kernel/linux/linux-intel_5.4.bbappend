FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ASoC-Intel-cht_bsw_rt5645-add-quirk-for-SSP0-AIF1-ro.patch"

