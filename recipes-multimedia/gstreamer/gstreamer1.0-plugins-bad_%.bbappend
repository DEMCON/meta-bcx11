# OpenGL in our BSP is weird, so disable this from bad plugins
PACKAGECONFIG_remove = "gl"
