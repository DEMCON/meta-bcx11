FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://10-pca9555.rules"
